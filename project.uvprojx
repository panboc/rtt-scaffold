# Keil uVision project project.uvprojx, settings and files
target rtthread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H745IGTx:CM4 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.4.0
  cpu: IRAM(0x10000000,0x00048000) IROM(0x08100000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: STM32H745xx, USE_HAL_DRIVER,CORE_CM4,VIRTIO_SLAVE_ONLY,NO_ATOMIC_64_SUPPORT,METAL_MAX_DEVICE_REGIONS=2,METAL_INTERNAL,RPMSG_BUFFER_SIZE=100
  c include: .;rt-thread\include;applications\task_main;applications\task_dsp;applications\task_rs485;applications\task_protocol_cvt;applications\task_web_comm;applications\task_led_button;applications\task_udisk;applications\task_module_detect;applications\task_log_data;applications\task_ground_fault;packages\lcd\task;board;driver\can;driver\sci;packages\lcd\driver;libraries\HAL_Drivers;libraries\HAL_Drivers\config;libraries\HAL_Drivers\drv_flash;middle\crc;middle\AES;middle\DSPComm;middle\link_list;middle\LinkProtocolCvt;middle\modbus;middle\parallelCommonLib;middle\protocol_aa55;middle\protocol_can;middle\HistoryData;middle\HistoryFault;packages\lcd\function;packages\agile_button-latest\examples;packages\agile_button-latest\inc;packages\agile_led-latest\examples;packages\agile_led-latest\inc;packages\eh-bluetooth;packages\fal-v0.5.0\inc;packages\fal-v0.5.0\samples\porting;packages\FlashDB-latest\inc;packages\meter-latest;packages\pcf8563;packages\peripheral_samples-latest;packages\spi_flash;packages\sunspec;rt-thread\libcpu\arm\common;rt-thread\libcpu\arm\cortex-m4;rt-thread\components\drivers\include;rt-thread\components\drivers\spi;rt-thread\components\drivers\include;rt-thread\components\drivers\spi\sfud\inc;rt-thread\components\drivers\include;rt-thread\components\finsh;rt-thread\components\libc\compilers\common;rt-thread\components\utilities\ulog;libraries\STM32H7xx_HAL\STM32H7xx_HAL_Driver\Inc;libraries\STM32H7xx_HAL\CMSIS\Device\ST\STM32H7xx\Include;libraries\STM32H7xx_HAL\CMSIS\Include;.\packages\CloudBoard;.\packages\at_device_comm;.\middle\AppModbus;.\applications\task_periodic;.\board\CubeMX_Config\Inc;.\libraries\STM32H7xx_HAL\CMSIS\Device\ST\STM32_USB_Host_Library\App\Inc;.\libraries\STM32H7xx_HAL\CMSIS\Device\ST\STM32_USB_Host_Library\Class\MSC\Inc;.\libraries\STM32H7xx_HAL\CMSIS\Device\ST\STM32_USB_Host_Library\Core\Inc;.\libraries\STM32H7xx_HAL\CMSIS\Device\Third_Party\FatFs\src;.\packages\udisk_ulog;.\packages\udisk_upgrade;.\middle\OpenAMP\Common\Inc;.\middle\OpenAMP\Common\Inc\openamp;.\middle\OpenAMP\open-amp\lib\include;.\middle\OpenAMP\libmetal\lib\include;.\middle\OpenAMP\libmetal\lib\include\metal;.\middle\OpenAMP\libmetal\lib\compiler\gcc;.\applications\task_arc;.\packages\safety_control\driver;.\packages\safety_control\function;.\packages\safety_control\function\dred_detect;.\packages\safety_control\function\hot_plug_detect;.\packages\safety_control\function\rcr_detect;.\packages\safety_control\function\shut_down;.\packages\safety_control\task
  memory RVCT4: ROM 0x8100000 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x48000
  scatter file: .\board\linker_scripts\link.sct
  group Kernel
    rt-thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group Applications
    applications/task_main/: main.c
    applications/task_meter/: task_meter.c
    applications/task_dsp/: task_dsp.c
    applications/task_can_recv/: task_can_recv.c
    applications/task_dsp_boot/: task_dsp_boot.c
    applications/task_rs485/: task_rs485.c
    applications/task_protocol_cvt/: task_protocol_cvt.c
    applications/task_web_comm/: task_web_comm.c
    applications/task_led_button/: task_led_button.c
    applications/task_udisk/: task_udisk.c
    applications/task_module_detect/: task_module_detect.c
    applications/task_log_data/: task_log_data.c
    applications/task_ground_fault/: task_ground_fault.c
    packages/lcd/task/: task_lcd.c
    ./applications/task_periodic/: task_periodic.c
    ./applications/task_arc/: task_arc_comm.c
    ./packages/safety_control/task/: task_safety_control.c
  group Drivers
    board/: board.c
    board/CubeMX_Config/Src/: stm32h7xx_hal_msp.c
    libraries/STM32H7xx_HAL/CMSIS/Device/ST/STM32H7xx/Source/Templates/arm/: startup_stm32h745xx.s
    driver/can/: drv_canport.c
    driver/sci/: drv_sci.c
    packages/lcd/driver/: drv_lcd1602.c
    libraries/HAL_Drivers/: drv_gpio.c drv_usart.c drv_hwtimer.c drv_spi.c drv_soft_i2c.c drv_can.c drv_common.c
    libraries/HAL_Drivers/drv_flash/: drv_flash_h7.c
    ./packages/safety_control/driver/: drv_adc.c
  group middle
    middle/crc/: crc_library.c
    middle/AES/: AES.c
    middle/DSPComm/: DSPComm.c
    middle/link_list/: link_list.c
    middle/LinkProtocolCvt/: LinkProtocolCvt.c
    middle/modbus/: modbus.c ModbusRegTable.c
    middle/parallelCommonLib/: parallelCommonLib.c parallelFuncCode.c
    middle/protocol_aa55/: protocol_aa55.c
    middle/protocol_can/: protocol_can.c
    middle/HistoryData/: HistoryData.c
    middle/HistoryFault/: HistoryFault.c
    packages/lcd/function/: lcd_fun.c
    ./packages/lcd/function/: lcd_fault_code.c
    ./middle/AppModbus/: app_modbus.c
  group at_device_comm
    ./packages/at_device_comm/: TaskTcpEc2x.c TaskTcpWifi.c TaskTcpA8500.c TaskLAN.c TaskBLT.c
  group safety_control
    ./packages/safety_control/function/dred_detect/: dred_detect.c
    ./packages/safety_control/function/hot_plug_detect/: hot_plut_detect.c
    ./packages/safety_control/function/rcr_detect/: rcr_detect.c
    ./packages/safety_control/function/shut_down/: shut_down.c
  group agile_button
    packages/agile_button-latest/examples/: example_agile_button.c
    packages/agile_button-latest/src/: agile_button.c
  group agile_led
    packages/agile_led-latest/examples/: example_agile_led.c
    packages/agile_led-latest/src/: agile_led.c led_service.c
  group CloudBoard
    ./packages/CloudBoard/: cloudboard.c
  group fal
    packages/fal-v0.5.0/src/: fal.c fal_flash.c fal_partition.c fal_rtt.c
    packages/fal-v0.5.0/samples/porting/: fal_flash_sfud_port.c fal_flash_stm32h7_port.c
  group FlashDB
    packages/FlashDB-latest/src/: fdb.c fdb_cmd.c fdb_file.c fdb_kvdb.c fdb_tsdb.c fdb_utils.c
  group meter
    packages/meter-latest/: meter.c meter_comm.c
  group pcf8563
    packages/pcf8563/: pcf8563.c
    packages/pcf8563/example/: example_pcf8563.c
  group spi_flash
    packages/spi_flash/: flash_app_port.c flash_fdb_port.c
  group sunspec
    packages/sunspec/: sunspec_485.c sunspec_dsp.c sunspec_model.c
  group cpu
    rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
  group DeviceDrivers
    rt-thread/components/drivers/can/: can.c
    rt-thread/components/drivers/hwtimer/: hwtimer.c
    rt-thread/components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    rt-thread/components/drivers/misc/: pin.c adc.c
    rt-thread/components/drivers/rtc/: rtc.c
    rt-thread/components/drivers/serial/: serial.c
    rt-thread/components/drivers/spi/: spi_core.c spi_dev.c spi_flash_sfud.c
    rt-thread/components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    rt-thread/components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/watchdog/: watchdog.c
  group finsh
    rt-thread/components/finsh/: shell.c cmd.c msh.c msh_file.c
  group libc
    rt-thread/components/libc/compilers/common/: time.c
  group Utilities
    rt-thread/components/utilities/ulog/: ulog.c
    rt-thread/components/utilities/ulog/backend/: console_be.c
  group STM32_HAL
    libraries/STM32H7xx_HAL/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
    libraries/STM32H7xx_HAL/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cec.c stm32h7xx_hal_cortex.c stm32h7xx_hal_comp.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_cryp.c stm32h7xx_hal_cryp_ex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_rng.c stm32h7xx_hal_sram.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_uart.c stm32h7xx_hal_usart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_qspi.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_hal_hcd.c stm32h7xx_ll_usb.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_lptim.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_iwdg.c stm32h7xx_hal_wwdg.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c
  group udisk
    ./packages/udisk_ulog/: udisk_ulog.c
    ./packages/udisk_upgrade/: udisk_upgrade.c
  group usb-host-msc
    ./libraries/STM32H7xx_HAL/CMSIS/Device/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
  group usb-core
    ./libraries/STM32H7xx_HAL/CMSIS/Device/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
  group usb-app
    ./libraries/STM32H7xx_HAL/CMSIS/Device/ST/STM32_USB_Host_Library/App/Src/: usbh_conf.c usbh_diskio.c
  group fatfs
    ./libraries/STM32H7xx_HAL/CMSIS/Device/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ./libraries/STM32H7xx_HAL/CMSIS/Device/Third_Party/FatFs/src/option/: syscall.c unicode.c
  group OpenAMP/libmetal
    ./middle/OpenAMP/libmetal/lib/: device.c init.c io.c log.c shmem.c
    ./middle/OpenAMP/libmetal/lib/system/generic/: irq.c time.c condition.c
    ./middle/OpenAMP/libmetal/lib/system/generic/cortexm/: sys.c
  group OpenAMP/libmetal/genric
    ./middle/OpenAMP/libmetal/lib/system/generic/: generic_device.c generic_init.c generic_io.c
  group OpenAMP/open-amp
    ./middle/OpenAMP/open-amp/lib/remoteproc/: remoteproc_virtio.c
    ./middle/OpenAMP/open-amp/lib/rpmsg/: rpmsg.c rpmsg_virtio.c
    ./middle/OpenAMP/open-amp/lib/virtio/: virtio.c virtqueue.c
  group OpenAMP/Common
    ./middle/OpenAMP/Common/Src/: mbox_hsem.c openamp.c rsc_table.c
